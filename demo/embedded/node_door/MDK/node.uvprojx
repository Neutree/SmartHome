# Keil uVision project node.uvprojx, settings and files
target node (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: node +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\lib\inc;..\app;..\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib/hal
    ../../lib/src/: F103_ADC_S.cpp F103_PWM.cpp GPIO.cpp LED.cpp StepMotor.cpp TaskManager.cpp Timer.cpp Voltage.cpp USART.cpp Socket_esp8266.cpp esp8266.cpp
  group lib/math
    ../../lib/src/: MD5.cpp CRC.cpp
  group app
    ../app/: app.cpp protocol.cpp
  group sys
    ../sys/: main.cpp hardware.cpp Interrupt.cpp
target target2 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: node
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
